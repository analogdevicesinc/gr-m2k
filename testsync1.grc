options:
  parameters:
    generate_options: qt_gui
    id: test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: m2k_analog_in_source_0
  id: m2k_analog_in_source
  parameters:
    buffer_size: '32768'
    calibrateADC: 'True'
    enable_ch1: 'True'
    enable_ch2: 'True'
    kernel_buffers: '4'
    oversampling_ratio: '1'
    range_1: '0'
    range_2: '0'
    sampling_frequency: '100000'
    trigger_condition_ch1: '0'
    trigger_condition_ch2: '0'
    trigger_delay: '0'
    trigger_level_ch1: '1'
    trigger_level_ch2: '1'
    trigger_mode_ch1: '0'
    trigger_mode_ch2: '0'
    trigger_source: '0'
    type: 'True'
    uri: ip:192.168.2.1
  states: {}
- name: m2k_digital_in_source_0
  id: m2k_digital_in_source
  parameters:
    buffer_size: '32768'
    channel: '0'
    kernel_buffers: '4'
    sampling_frequency: '100000'
    sync_with_analog: 'True'
    uri: ip:192.168.2.1
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    nconnections: '3'
    size: '800'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_short_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [m2k_analog_in_source_0, '0', qtgui_time_sink_x_0, '1']
- [m2k_analog_in_source_0, '1', qtgui_time_sink_x_0, '2']
- [m2k_digital_in_source_0, '0', blocks_short_to_float_0, '0']

metadata:
  file_format: 1
