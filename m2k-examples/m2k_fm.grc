options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: adc_samp_rate
  id: variable
  parameters:
    value: '100000000'
  states: {}
- name: os_ratio
  id: variable
  parameters:
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: adc_samp_rate/os_ratio
  states: {}
- name: uri
  id: variable
  parameters:
    value: '"ip:192.168.2.1"'
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,2
    label: Offset
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: int(samp_rate/2)
    value: '25000'
  states: {}
- name: variable_qtgui_range_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Volume
    orient: Qt.Horizontal
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0.2'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: variable_qtgui_range_0
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: '250000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: variable_qtgui_range_1
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '2048'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '100000'
    decim: '8'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '10000'
    win: firdes.WIN_HAMMING
  states: {}
- name: m2k_adf4350_sink_1
  id: m2k_adf4350_sink
  parameters:
    anti_backlash_3ns_enable: '0'
    aux_output_enable: '0'
    aux_output_fundamental_enable: '1'
    aux_output_power: '0'
    band_select_clock_mode_high_enable: '0'
    channel_spacing: '10000'
    charge_cancellation_enable: '0'
    charge_pump_current: '2500'
    chip_select: '2'
    clk_divider_12bit: '0'
    clk_divider_mode: '0'
    clkin: '10000000'
    clock: '0'
    cycle_slip_reduction_enable: '0'
    lock_detect_function_integer_n_enable: '0'
    lock_detect_precision_6ns_enable: '0'
    low_spur_mode_enable: '0'
    miso: '7'
    mosi: '1'
    mute_till_lock_enable: '0'
    muxout_select: '1'
    output_power: '3'
    phase_detector_polarity_positive_enable: '1'
    power_up_frequency: '100000000'
    reference_div2_enable: '0'
    reference_div_factor: '0'
    reference_doubler_enable: '0'
    uri: uri
  states: {}
- name: m2k_analog_in_source_0
  id: m2k_analog_in_source
  parameters:
    buffer_size: '0x10000'
    calibrateADC: 'False'
    enable_ch1: 'True'
    enable_ch2: 'False'
    kernel_buffers: '4'
    oversampling_ratio: os_ratio
    range_1: '1'
    range_2: '1'
    sampling_frequency: adc_samp_rate
    trigger_condition_ch1: '0'
    trigger_condition_ch2: '0'
    trigger_delay: '0'
    trigger_level_ch1: '1'
    trigger_level_ch2: '1'
    trigger_mode_ch1: '0'
    trigger_mode_ch2: '0'
    trigger_source: '0'
    type: 'False'
    uri: uri
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: 0,0,1,1
    key: frequency
    label: PLL Frequency
    type: string
    value: '100000000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '16382'
    freqhalf: 'False'
    gui_hint: 9,0,2,1
    name: '"RAW-FFT"'
    showports: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 6,0,3,2
    name: '"LPF"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 9,1,2,1
    label1: ''
    name: '"RAW"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,0,4,2
    name: '"Waterfall"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '250'
    interp: '48'
    taps: ''
    type: fff
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_multiply_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_short_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_short_to_float_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_short_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [m2k_analog_in_source_0, '0', blocks_short_to_float_0, '0']
- [qtgui_edit_box_msg_0, msg, m2k_adf4350_sink_1, msg]
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
